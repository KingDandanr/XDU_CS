ADDR_0832       EQU     0240H			;0832输出口地址

_STACK	SEGMENT	STACK	
	DW	100 DUP(?)	
_STACK	ENDS		
			
_DATA	SEGMENT	WORD PUBLIC 'DATA'
TAB_1   DB      7FH,8BH,96H,0A1H,0ABH,0B6H,0C0H,0C9H,0D2H
        DB      0DAH,0E2H,0E8H,0EEH,0F4H,0F8H,0FBH,0FEH,0FFH,0FFH
        DB      0FFH,0FEH,0FBH,0F8H,0F4H,0EEH,0E8H,0E2H,0DAH,0D2H
        DB      0C9H,0C0H,0B6H,0ABH,0A1H,096H,08BH,07FH
        DB      74H,69H,5EH,54H,49H,40H,36H,2DH,25H,1DH,17H,11H,0BH,7,4,2,0,0
        DB      0,2,4,7,0BH,11H,17H,1DH,25H,2DH,36H,40H,49H,54H,5EH,69H,74H
_DATA	ENDS		
			
CODE	SEGMENT		
START	PROC	NEAR	
	ASSUME	CS:CODE, DS:_DATA, SS:_STACK
	MOV	AX,_DATA	
        MOV     DS,AX
        nop
	MOV     DX,ADDR_0832
START1: LEA	SI,TAB_1
        MOV     CX,72
START2: LODSB	
        OUT     DX,AL
        CALL    DELAY
        LOOP    START2
  	JMP	START1
 
DELAY	PROC	NEAR
	PUSH	CX
	MOV	CX,80
	LOOP	$	
	POP	CX
	RET
DELAY	ENDP	
        
START	ENDP		
CODE	ENDS		
        END     START
